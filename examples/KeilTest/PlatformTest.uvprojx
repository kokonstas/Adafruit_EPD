# Keil uVision project PlatformTest.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.35.0
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x00800000,0x00040000) IROM(0x00000000,0x00100000) IROM2(0x12000000,0x08000000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: PlatformTest
  c flags: Optim=1 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=1
  memory RVCT5: ROM 0x12000000 size 0x8000000
  group Source Group 1
    ../../src/: EPDTest.c glcdfont.c Adafruit_EPD.cpp Adafruit_GFX.cpp Adafruit_MCPSRAM.cpp Adafruit_SPITFT.cpp SPI.cpp
    ../../src/drivers/: Adafruit_IL0373.cpp Adafruit_IL0398.cpp Adafruit_IL91874.cpp Adafruit_SSD1608.cpp Adafruit_SSD1619.cpp Adafruit_SSD1675.cpp Adafruit_SSD1675B.cpp Adafruit_SSD1680.cpp Adafruit_SSD1681.cpp
software components: CMSIS:CORE 5.1.2, Device:Startup 8.35.0
